# Keil uVision project application.uvproj, settings and files
target devkit (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: devkit +hex
  c flags: Optim=2 uC99=1 wLevel=2
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, USE_DHCP
  c include: .\app\inc;.\support\CMSIS\Include;.\support\STM32F4x7_ETH_Driver\inc;.\support\STM32F4xx_StdPeriph_Driver\inc;.\support\STM32F4-Discovery;.\support\lwip_v1.3.2\port\STM32F4x7;.\support\lwip_v1.3.2\src\include;.\support\lwip_v1.3.2\src\include\ipv4;.\support\lwip_v1.3.2\src\include\lwip;.\support\lwip_v1.3.2\src\include\netif;.\support\lwip_v1.3.2\port\STM32F4x7\FreeRTOS;.\support\FreeRTOS\include;.\support\FreeRTOS\portable\RVDS\ARM_CM4F;.\support\FreeRTOS\CMSIS_RTOS;.\common\inc;.\support\Si4463\drivers\radio\Si446x;.\support\Si4463\drivers\radio;..\..\project-dandelion\devkit\cross-platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app/src
    ./app/src/: main.c netconf.c stm32f4xx_it.c system_stm32f4xx.c stm32f4x7_eth_bsp.c tcpecho.c debug.c console.c radio.c ftp.c time_sync.c
    ../../project-dandelion/devkit/cross-platform/src/: sensor_conversions.c
  group STM32F4xx_StdPeriph_Driver
    ./support/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ./support/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_rtc.c
  group FreeRTOS
    ./support/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./support/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./support/FreeRTOS/portable/MemMang/: heap_4.c
    ./support/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group LWIP
    ./support/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
    ./support/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./support/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./support/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./support/lwip_v1.3.2/src/netif/: etharp.c
  group app/inc
    ./app/inc/: radio.h netconf.h serial_debug.h stm32f4x7_eth_bsp.h stm32f4x7_eth_conf.h stm32f4xx_conf.h stm32f4xx_it.h main.h lwipopts.h FreeRTOSConfig.h debug.h console.h ftp.h time_sync.h
    ../../project-dandelion/devkit/cross-platform/inc/: radio_packets.h
    ./common/inc/: app_header.h
  group bsp/src
    ../../project-dandelion/devkit/cross-platform/src/: xprintf.c
    ./support/STM32F4-Discovery/: stm32f4_discovery.c
    ./app/: startup_stm32f407xx.s
    ./app/src/: uart.c spi.c
  group bsp/inc
    ../../project-dandelion/devkit/cross-platform/inc/: xprintf.h
    ./app/inc/: spi.h uart.h
  group Si4436
    ./support/Si4463/drivers/radio/: radio_comm.c radio_comm.h radio_hal.c radio_hal.h
    ./support/Si4463/drivers/radio/Si446x/: si446x_api_lib.c si446x_api_lib.h si446x_cmd.h si446x_defs.h si446x_nirq.c si446x_nirq.h si446x_patch.h si446x_prop.h

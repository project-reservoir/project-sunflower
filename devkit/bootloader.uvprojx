# Keil uVision project bootloader.uvprojx, settings and files
target devkit (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\bootloader\inc;.\bootloader\conf;.\common\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./bootloader/src/: system_interrupts.c main.c launch.s
  group inc
    ./bootloader/inc/: hwctrl.h system_interrupts.h
    ./common/inc/: app_header.h
